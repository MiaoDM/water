# Keil uVision project USART.uvprojx, settings and files
target BC28_Transport_tem (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\HARDWARE\BC28;..\HARDWARE\TIME;..\HARDWARE\LCD;..\HARDWARE\COMMON;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\STRHEX;..\HARDWARE\ADC;..\HARDWARE\DS18B20;..\HARDWARE\GPS;..\SYSTEM\usart;..\HARDWARE\HC05
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/BC28/: bc28.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TIME/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/STRHEX/: HEXSTR.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/COMMON/: common.c
    ../HARDWARE/DS18B20/: DS18B20.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/HC05/: hc05.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_wwdg.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_sai.c stm32f4xx_rtc.c stm32f4xx_rng.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c
  group README
    ../: readme.txt
